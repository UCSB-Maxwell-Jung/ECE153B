# Keil uVision project ece153b_lab.uvprojx, settings and files
target release (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ece153b_lab +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\AppData\Local\Arm\Packs\Keil\STM32L4xx_DFP\2.6.1\Drivers\CMSIS\Device\ST\STM32L4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group lab1
    ./src/lab1/: main.c startup_stm32l476xx.s stm32l476xx.h
  group lab2a
    ./src/lab2a/: Button.c Button.h EXTI.c EXTI.h LED.c LED.h main.c startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h
  group lab2b
    ./src/lab2b/: LED.c LED.h main.c startup_stm32l476xx.s stm32l476xx.h SysTimer.c SysTimer.h
  group lab2c
    ./src/lab2c/: LED.c LED.h main.c RTC.c RTC.h startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h
  group lab3a
    ./src/lab3a/: main.c startup_stm32l476xx.s stm32l476xx.h
  group lab3b
    ./src/lab3b/: main.c startup_stm32l476xx.s stm32l476xx.h
  group lab4a
    ./src/lab4a/: LED.c LED.h main.c startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h UART.c UART.h UART_printf.c
  group lab4b
    ./src/lab4b/: I2C.c I2C.h main.c startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h UART.c UART.h UART_printf.c
  group lab4c
    ./src/lab4c/: LED.c LED.h main.c SPI.c SPI.h startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h SysTimer.c SysTimer.h
  group lab5a
    ./src/lab5a/: ADC.c ADC.h main.c PWM.c PWM.h startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h
  group lab5b
    ./src/lab5b/: ADC.c ADC.h DAC.c DAC.h EXTI.c EXTI.h main.c PWM.c PWM.h startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h Button.c Button.h
  group lab6a
    ./src/lab6a/: main.c startup_stm32l476xx.s stm32l476xx.h
  group lab6b
    ./src/lab6b/: main.c startup_stm32l476xx.s stm32l476xx.h
  group final
    ./src/final/: Adafruit_GFX.cpp Adafruit_GFX.h Adafruit_ILI9341.cpp Adafruit_ILI9341.h Adafruit_ImageReader.cpp Adafruit_ImageReader.h Adafruit_SPITFT.cpp Adafruit_SPITFT.h dragon.h FatStructs.h File.cpp gfxfont.h glcdfont.c hardware_spi1.cpp hardware_spi1.h hardware_spi3.cpp hardware_spi3.h hardware_usart1.cpp hardware_usart1.h hardware_usart2.cpp hardware_usart2.h LED.cpp LED.h main.cpp nucleo.h Print.cpp Print.h SD.cpp SD.h Sd2Card.cpp Sd2Card.h Sd2PinMap.h SdFat.h SdFatUtil.h SdFile.cpp SdInfo.h SdVolume.cpp SPI.cpp SPI.h startup_stm32l476xx.s stm32l476xx.h Stream.cpp Stream.h SysClock.cpp SysClock.h SysTick.c SysTick.h UART.cpp UART.h image_reader_test.cpp image_reader_test.h
software components: CMSIS:CORE 5.6.0
